# IAR project RTL8195A.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG__
  ICCARM.CCIncludePath2: Source\App; Source\RTOS; Library\RTOS; Library\MCU\CMSIS; Library\MCU\FWLIB; Library\MCU\ROM; Library\MCU\WLAN
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTL8195A.srec
  ILINK.IlinkOutputFile: RTL8195A.out
  ILINK.IlinkIcfFile: Linker\rtl8195a_btl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Library/MCU/CMSIS
    Library/MCU/CMSIS/: rtl8195a.h startup_rtl8195a.s system_rtl8195a.c system_rtl8195a.h
  group Library/RTOS
    Library/RTOS/: cmsis_os2.h core_cm.h core_cm_Override.h irq_cm3.s irq_cm4f.s RTE_Components.h rtx_delay.c rtx_evflags.c rtx_kernel.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_os.h rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c user_svc.c
  group Linker
    Linker/: rtl8195a_app.icf rtl8195a_btl.icf
  group Source/App
    Source/App/: main.c
  group Source/RTOS
    Source/RTOS/: RTX_Config.c RTX_Config.h
